## boards/shields/keybird/Kconfig.defconfig
```kconfig
if SHIELD_KEYBIRD

config ZMK_KEYBOARD_NAME
  default "Keybird"

endif
CONFIG_ZMK_KEYBOARD_NAME="Keybird"
```
